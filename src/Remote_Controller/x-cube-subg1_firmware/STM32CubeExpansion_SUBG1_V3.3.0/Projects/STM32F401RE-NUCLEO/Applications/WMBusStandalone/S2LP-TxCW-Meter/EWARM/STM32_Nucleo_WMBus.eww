<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\STM32_Nucleo_WMBus.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>wMBus_NUCLEO_F4</name>
            <member>
                <project>STM32_Nucleo_WMBus</project>
                <configuration>S2LP-CONC-PC-GUI</configuration>
            </member>
            <member>
                <project>STM32_Nucleo_WMBus</project>
                <configuration>S2LP-ConnectionApplyingTPL-Conc</configuration>
            </member>
            <member>
                <project>STM32_Nucleo_WMBus</project>
                <configuration>S2LP-ConnectionApplyingTPL-Meter</configuration>
            </member>
            <member>
                <project>STM32_Nucleo_WMBus</project>
                <configuration>S2LP-FrequentAccessCycle-Conc</configuration>
            </member>
            <member>
                <project>STM32_Nucleo_WMBus</project>
                <configuration>S2LP-FrequentAccessCycle-Meter</configuration>
            </member>
            <member>
                <project>STM32_Nucleo_WMBus</project>
                <configuration>S2LP-Installation-Conc</configuration>
            </member>
            <member>
                <project>STM32_Nucleo_WMBus</project>
                <configuration>S2LP-Installation-Meter</configuration>
            </member>
            <member>
                <project>STM32_Nucleo_WMBus</project>
                <configuration>S2LP-METER-PC-GUI</configuration>
            </member>
            <member>
                <project>STM32_Nucleo_WMBus</project>
                <configuration>S2LP-RFConnectionUsingSND-UD2-Conc</configuration>
            </member>
            <member>
                <project>STM32_Nucleo_WMBus</project>
                <configuration>S2LP-RFConnectionUsingSND-UD2-Meter</configuration>
            </member>
            <member>
                <project>STM32_Nucleo_WMBus</project>
                <configuration>SPIRIT1-Meter-868MHz</configuration>
            </member>
            <member>
                <project>STM32_Nucleo_WMBus</project>
                <configuration>S2LP-AccessDemand-Conc</configuration>
            </member>
            <member>
                <project>STM32_Nucleo_WMBus</project>
                <configuration>S2LP-AccessDemand-Meter</configuration>
            </member>
            <member>
                <project>STM32_Nucleo_WMBus</project>
                <configuration>S2LP-RxPER-Meter</configuration>
            </member>
            <member>
                <project>STM32_Nucleo_WMBus</project>
                <configuration>S2LP-TxCW-Meter</configuration>
            </member>
            <member>
                <project>STM32_Nucleo_WMBus</project>
                <configuration>S2LP-TXPN9-Meter</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
